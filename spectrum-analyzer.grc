options:
  parameters:
    author: JK
    generate_options: qt_gui
    id: spectrum_analyzer
    max_nouts: '1'
    output_language: python
    title: spectrum_analyzer
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: '1000'
    step: '1000000'
    stop: '10000000'
    value: '10000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '1000000'
    step: '8000000'
    stop: '6000000000'
    value: '2400000000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '1000000'
    step: '1000000'
    stop: 20e6
    value: 10e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '15'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: 10e6
    clock_source0: internal
    freq0: freq
    gain0: vga_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: freq
    fftsize: '1024'
    name: qtgui
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-682-gdd442bda
