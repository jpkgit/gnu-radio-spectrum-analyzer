options:
  parameters:
    author: JK
    generate_options: qt_gui
    id: spectrum_analyzer
    max_nouts: '1'
    output_language: python
    title: spectrum_analyzer
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: '1000'
    step: '1000'
    stop: '10000000'
    value: '10000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '1000000'
    step: '8000000'
    stop: '6000000000'
    value: '2400000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '15'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '1000000'
    step: '1000000'
    stop: '20000000'
    value: '1000000'
  states: {}
- name: variable_qtgui_check_box_sweep
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Sweep
    'true': 'True'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_range_sweep_speed
  id: variable_qtgui_range
  parameters:
    label: Sweep Speed (ms)
    start: '0.001'
    step: '0.001'
    stop: '100'
    value: '0.005'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    bw0: bandwidth
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: freq
    fftsize: '4096'
    name: '"Spectrum Analyzer"'
    rate: '20'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-682-gdd442bda
