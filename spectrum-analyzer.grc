options:
  parameters:
    author: JK
    generate_options: qt_gui
    id: spectrum_analyzer
    max_nouts: '1'
    output_language: python
    title: spectrum_analyzer
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    start: '1000'
    step: '1000'
    stop: '10000000'
    value: '10000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '15'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '1000000'
    step: '1000000'
    stop: '20000000'
    value: '1000000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '1000000'
    step: '8000000'
    stop: '6000000000'
    value: '2400000000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '4096'
    name: '"Spectrum Analyzer"'
    rate: '20'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: bandwidth
    center_freq: tuning
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: gain
  states: {}

connections:
- [qtgui_sink_x_0, freq, soapy_hackrf_source_0, cmd]
- [soapy_hackrf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
